# Repository mcauser/Grove-Eagle

## EAGLE design DMX512/v1.0/Grove - DMX512 v1.0.brd

Parts:
C1: 100nf; C0603
J1: TWIG-4P-2.0-2.0; 4P-2.0
J2: H22; 3P-4.0
R1: 100_1%; R0603
U1: SN75176; SOIC8

Connections:
GND: C1.1, J1.4, J2.1, R1.1, U1.2 (!RE), U1.5 (GND)
unnamed: R1.2, U1.1 (R)
unnamed: J2.3, U1.6 (A)
unnamed: J2.2, U1.7 (B)
NC: J1.2
SIG: J1.1, U1.4 (D)
VCC: C1.2, J1.3, U1.3 (DE), U1.8 (VCC)

Notes on the sheet:
Wangcf
Albert
v1.0
3/20/2013

Board: 2 copper layers, 41.9 x 23.8 mm, 8 parts (2 on the bottom side), 6 nets.

Other parts of the board:
U$4: 2U-DIM-W/DRILL
U$5: OSHW_FILLX200_NOTEXT
U$6: TWIGLOGO

## EAGLE design Differential Amplifier/v0.9b/Amplifier.brd

Parts:
C1: 100nf; C0805
GAIN: SW-2H-3P; 3P-2CH-3.54X8.5
J1: Grove; 4P-2.0
J2: Male; 4P-65/35MIL
P1, P2: PAD-MARK; ROUND-MARK-1.0
R1: 62R_0.1%; R0805
R3: 200R_0.1%; R0805
U1: INA125; SO16

Connections:
GND: C1.2, J1.4, J2.4, U1.3 (V-), U1.5 (IAREF), U1.12 (VREFCOM)
unnamed: GAIN.2 (COM), U1.9 (RG)
unnamed: GAIN.1 (A), R1.2
unnamed: GAIN.3 (B), R3.2
unnamed: R1.1, R3.1, U1.8 (RG)
NC: J1.2
SIG: J1.1, U1.10 (VO), U1.11 (SENSE)
VCC: C1.1, J1.3, J2.3, U1.1 (V+), U1.2 (!SLEEP)
VIN+: J2.2, U1.6 (VIN+)
VIN-: J2.1, U1.7 (VIN-)
VREF: U1.4 (VREFOUT), U1.15 (VREF5)

Notes on the sheet:
增益电阻

Board: 2 copper layers, 42.1 x 24.2 mm, 12 parts (2 on the bottom side), 10 nets.

Other parts of the board:
U$1: 2U-DIM-W/DRILL
U$3: TWIGLOGO
U$4: OSHW_FILLX200_NOTEXT

## EAGLE design Differential Amplifier/v1.1/Grove - Differential Amplifier v1.1.brd

Parts:
C1, C2, C3, C4: C-0603; C0603
J3: Male; 4P-65/35MIL
J4: Grove; 4P-2.0
P1, P2, P3, P4: PAD-MARK; ROUND-MARK-1.0
R1: 30k_1%; R0603
R2: 20k_1%; R0603
R3, R4: 340k_1%; R0603
R5: 1k_1%; R0603
SW: SW-2H-3P; 3P-2CH-3.54X8.5
U1, U3, U4: OPA333DBV; SOT23-5
U2: INA132U/2K5; SOIC8-6.0

Connections:
5V: C1.1, C2.1, C3.2, C4.1, J3.3, J4.3, U1.5 (V+), U2.7 (V+), U3.5 (V+), U4.5 (V+)
GND: C1.2, C2.2, C3.1, C4.2, J3.4, J4.4, R5.2, U1.2 (V-), U2.1 (REF), U2.4 (V-), U3.2 (V-), U4.2 (V-)
unnamed: R1.1, R5.1, U1.4 (-IN)
unnamed: R1.2, SW.1 (A), U1.1 (OUT)
unnamed: R2.1, R4.2, U3.4 (-IN)
unnamed: R2.2, R3.2, U4.4 (-IN)
unnamed: R3.1, U2.2 (-IN), U4.1 (OUT)
unnamed: R4.1, U2.3 (+IN), U3.1 (OUT)
SIG: J4.1, SW.2 (COM)
SIG0: SW.3 (B), U1.3 (+IN), U2.5 (SENSE), U2.6 (OUTPUT)
V+: J3.2, U3.3 (+IN)
V-: J3.1, U4.3 (+IN)

Notes on the sheet:
1020

Board: 2 copper layers, 83.8 x 103.9 mm, 30 parts (2 on the bottom side), 12 nets.

Other parts of the board:
U$12, U$15, U$16, U$17, U$18, U$19, U$20, U$21: 2U-DIM-W/DRILL
U$13: OSHW_FILLX200_NOTEXT
U$14: TWIGLOGO

## EAGLE design Digital Infrared Temperature Sensor/v1.0/Grove - Digital Infrared Temperature Sensor v1.0.brd

Parts:
C1, C2, C5: 100nF; C0603
C3, C4: DNP; C0603
C12: 16V 10uF; AVX-A
J1: SMD-Grove; 4P-SMD-2.0
Q1, Q2: 2N7002; SOT23
R1, R3, R4, R5: 4.7k; R0603
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: PAD-TEST-POINT'4545'; TP-D45MIL
U1: XC6206302MR; SOT23
U2: MLX90615SSG; 4P-D5.4MM*2.7H

Connections:
3V: C2.1, C5.1, C12.+, Q1.1 (G), Q2.1 (G), R1.1, R3.1, TP6.T, U1.2 (VOUT), U2.2 (VDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C12.-, J1.4, J1.SS1, J1.SS2, TP4.T, U1.1 (VSS), U2.4 (VSS)
unnamed: C4.1, Q1.2 (S), R3.2, U2.3 (SCL)
unnamed: C3.1, Q2.2 (S), R1.2, U2.1 (SDA)
SCL: J1.1, Q1.3 (D), R4.2, TP1.T
SDA: J1.2, Q2.3 (D), R5.2, TP2.T
VCC: C1.1, J1.3, R4.1, R5.1, TP3.T, U1.3 (VIN)

Notes on the sheet:
Vincent
V1.0

Parts:
P1, P2, P3, P4, P5, P6, P7, P8: PAD-MARK; ROUND-MARK-1.0
U3, U4, U5, U6, U7, U8, U9, U10: TWIG'2U'; GROVE-TEST-PLATFORM

Board: 2 copper layers, 83.8 x 128.0 mm, 44 parts (15 on the bottom side), 7 nets.

Other parts of the board:
U11, U12: GROVE-TEST-PLATFORM@1
U$2: GROVE-SILK-BIG
U$4: GROVE-1*2-TEST-PLATFORM
U$5: OSHW_FILLX200_NOTEXT

## EAGLE design Digital Light Sensor/v0.9b/Digital light sensor v0.9b.brd

Parts:
C1, C2: 1uF; C0603
C3: 100nF; C0603
J1: Grove; 4P-2.0
Q1, Q2: BSN20; SOT23
R1, R2, R3, R4: 10K; R0603
U1: TSL2561; TMB-6
U3: XC6206MR; SOT23

Connections:
3.3V: C2.2, C3.2, Q1.1 (G), Q2.1 (G), R1.2, R2.2, U1.1 (VDD), U3.2 (VOUT)
5V: C1.2, J1.3, R3.2, R4.2, U3.3 (VIN)
GND: C1.1, C2.1, C3.1, J1.4, U1.2 (ADDR), U1.3 (GND), U3.1 (VSS)
SCL: J1.1, Q2.3 (D), R3.1
SDA: J1.2, Q1.3 (D), R4.1
T_SCL: Q2.2 (S), R2.1, U1.4 (SCL)
T_SDA: Q1.2 (S), R1.1, U1.6 (SDA)

Notes on the sheet:
稳压电路
逻辑电平转换电路

Board: 2 copper layers, 20.0 x 24.2 mm, 15 parts (2 on the bottom side), 7 nets.

Other parts of the board:
U$2: 1U-DIM-W/-DRILL
U$3: TWIGLOGO
U$4: OSHW_FILLX200_NOTEXT

## EAGLE design Dry-Reed Relay/v1.0b/Grove - Dry-Reed Relay v1.0b.brd

Parts:
C1: 100pF; C0603
D1: LL4148ST; DO-35-SMD
D2: Green; LED-0603
J1: Grove-4P; 4P-2.0
J2: GSL009-5.0-02P-12; 2P-5.08
Q1: S9013; SOT23
R1: 2k; R0603
R2: 100K; R0603
R3: 1K; R0603
R4: 100; R0603
U1: Dry-Reed Relay; 4P-25.2X8X9H

Connections:
GND: J1.4, Q1.2 (E), R2.1
unnamed: C1.1, Q1.1 (B), R1.2
unnamed: D2.+, R3.2
unnamed: C1.2, D1.A (+), D2.-, Q1.3 (C), U1.1
unnamed: J2.1, U1.4
unnamed: J2.2, U1.3
unnamed: R4.2, U1.2
NC: J1.2
SIG: J1.1, R1.1, R2.2
VCC: D1.C (-), J1.3, R3.1, R4.1

Board: 2 copper layers, 41.9 x 23.8 mm, 14 parts (2 on the bottom side), 9 nets.

Other parts of the board:
U$3: 2U-DIM-W/DRILL
U$4: OSHW_FILLX200_NOTEXT
U$5: TWIGLOGO

## EAGLE design EL Driver/v1.0/Grove - EL Driver v1.0.brd

Parts:
C1, C2, C4: 4.7uF; C0805
C3: 100nF 50V; C0603
C5, C8: 100nF; C0603
C6: 10uF; C0805
C9: 100uF_6.3V; AVX-B
D2: SS14; DO-214AC
J1: SMD PH2.0-2P; SMD-PH2.0-2P
J2: SMD Grove; 4P-SMD-2.0
L2: CD32-4R7; SD32-4R7MC
Q1, Q2: SS8550; SOT-23
Q4: S9013W; SOT-323
R1, R3, R5, R8, R9: 1K; R0603
R2, R4: 22R; R0603
R6: 10K; R0603
R7: 22k 1%; R0603
R10: 3k 1%; R0603
R11, R12: 10k; R0603
T1: EPC-10; EPC-1003-4+4PIN
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: PAD-TEST-POINT'4545'; TP-D45MIL
U1: SX1301; SOT23-6L

Connections:
5V: C4.1, C8.1, C9.+, D2.2 (-), Q1.2 (E), Q2.2 (E), R6.2, R7.1, TP1.T
GND: C4.2, C5.1, C6.1, C8.2, C9.-, J2.4, J2.SS1, J2.SS2, Q4.2 (E), R9.2, R10.2, R11.1, T1.2, TP4.T, U1.2 (GND)
unnamed: C2.2, Q2.3 (C), T1.1
unnamed: R1.2, R3.1, R5.2
unnamed: C3.2, Q2.1 (B), R3.2, R4.1
unnamed: C1.1, R4.2
unnamed: Q4.3 (C), R5.1, R6.1
unnamed: C3.1, Q1.1 (B), R1.1, R2.1
unnamed: C1.2, Q1.3 (C), T1.3
unnamed: J1.2, T1.8
unnamed: C2.1, R2.2
unnamed: J1.1, T1.5
unnamed: R11.2, U1.6 (OC)
unnamed: D2.1 (+), L2.2, U1.1 (LX)
unnamed: R7.2, R10.1, U1.3 (FB)
unnamed: Q4.1 (B), R8.2, R9.1
unnamed: R12.1, U1.4 (EN)
SIG: J2.1, R8.1, TP2.T
VCC: C5.2, C6.2, J2.3, L2.1, R12.2, TP3.T, U1.5 (VCC)

Notes on the sheet:
Xiangnan.Qu
